# Keil uVision project dmac_lpc176x.uvprojx, settings and files
target Release (6150000::V6.15::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dmac_lpc176x +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: DMACU_QUIET=1,DMACU_ROM_ALIGNMENT=0x4,DMACU_VIRTUAL_PL080=0
  c misc: -Wall -Wno-c11-extensions -pedantic
  c include: ..\..\..\vcpu
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\lpc176x.sct
  link misc: --predefine="-DDMACU_VIRTUAL_PL080=0"
  group vcpu
    ../../../vcpu/: dmacu.h dmacu_instance.c dmacu_instance.h dmacu_shared.c rt.c utils.c vpl080.c
  group port
    ./: lpc176x.c lpc176x.sct
  group mc
    ../../../vcpu/mc/: demo.code.inc demo.data.inc
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
